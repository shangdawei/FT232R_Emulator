# IAR project FT232R_Emulator_Loader.ewp, settings and files
configuration STM32F0XX_Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: EXT_CLOCK=8000000; SYS_CLOCK=48000000; STM32F072CB; DEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\c; $TOOLKIT_DIR$\CMSIS\Include; Source; Source\STM32F0XX; Common\Algorithm; Common\Component; Common\Debug; Common\Driver; Common\Misc; Common\RTOS; Common\USB; MCU\STM32F0XX\Driver; MCU\STM32F0XX\Library\CMSIS; MCU\STM32F0XX\Library\SPL; MCU\STM32F0XX\Library\USB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32F072CB
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MCU\STM32F0XX\Linker\stm32f0xx_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F0XX_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072C8 ST STM32F072C8
  ICCARM.CCDefines: EXT_CLOCK=8000000; SYS_CLOCK=48000000; STM32F072C8
  ICCARM.CCOptLevel: 0
  AARM.ADefines: STM32F072C8
  OBJCOPY.OOCOutputFile: FT232R_Emulator_Loader.hex
  postbuild: post-build.bat "$PROJ_DIR$"
  ILINK.IlinkIcfFile: MCU\STM32F0XX\Linker\stm32f0xx_flash.icf
  group (top)
    ./: post-build.bat
  group Common/Component
    Common/Component/: EEPROM_Emulator.c EEPROM_Emulator.h
  group Common/Debugging
    Common/Debugging/: SEGGER_HardFault_Handler.S SEGGER_HardFaultHandler.c
  group Common/Driver
    ../../Common/Driver/: Driver_EEPROM_Emulator.h
  group Common/Misc
    Common/Misc/: compiler.h datetime.c datetime.h fifo.c fifo.h utility.c utility.h
  group Common/USB
    Common/USB/: usb_type.h usbd.h
  group MCU/STM32F0XX/Driver
    ../../MCU/STM32F0XX/Driver/: stm32f0xx_driver_eeprom.c
  group MCU/STM32F0XX/Library/CMSIS
    MCU/STM32F0XX/Library/CMSIS/: startup_stm32f0xx.s stm32f0xx.h stm32f0xx_0.h stm32f0xx_1.h stm32f0xx_2.h stm32f0xx_3.h stm32f0xx_4.h stm32f0xx_5.h stm32f0xx_6.h stm32f0xx_7.h stm32f0xx_8.h stm32f0xx_device.h system_stm32f0xx.c system_stm32f0xx.h
    ../../MCU/STM32F0XX/Library/CMSIS/: stm32f0xx_conf.h
  group MCU/STM32F0XX/Library/SPL
    ../../MCU/STM32F0XX/Library/SPL/: stm32f0xx_adc.c stm32f0xx_adc.h stm32f0xx_can.c stm32f0xx_can.h stm32f0xx_cec.c stm32f0xx_cec.h stm32f0xx_comp.c stm32f0xx_comp.h stm32f0xx_crc.c stm32f0xx_crc.h stm32f0xx_crs.c stm32f0xx_crs.h stm32f0xx_dac.c stm32f0xx_dac.h stm32f0xx_dbgmcu.c stm32f0xx_dbgmcu.h stm32f0xx_dma.c stm32f0xx_dma.h stm32f0xx_exti.c stm32f0xx_exti.h stm32f0xx_flash.c stm32f0xx_flash.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_i2c.c stm32f0xx_i2c.h stm32f0xx_iwdg.c stm32f0xx_iwdg.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_pwr.c stm32f0xx_pwr.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_rtc.c stm32f0xx_rtc.h stm32f0xx_spi.c stm32f0xx_spi.h stm32f0xx_syscfg.c stm32f0xx_syscfg.h stm32f0xx_tim.c stm32f0xx_tim.h stm32f0xx_usart.c stm32f0xx_usart.h stm32f0xx_wwdg.c stm32f0xx_wwdg.h
  group MCU/STM32F0XX/Library/USB
    MCU/STM32F0XX/Library/USB/: usb_bsp.c usb_bsp.h usb_conf.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_regs.h usbd.c usbd_core.c usbd_core.h usbd_ctrlreq.c usbd_ctrlreq.h usbd_def.h usbd_ioreq.c usbd_ioreq.h usbd_pwr.c usbd_pwr.h usbd_usr.c usbd_usr.h
  group Source
    Source/: FT232R_Emulator.c FT232R_Emulator.h FT232R_Emulator_BSP.h FT232R_Emulator_Descriptor.c FT232R_Emulator_Descriptor.h FT232R_Emulator_Eeprom.c FT232R_Emulator_Eeprom.h FT232R_Emulator_Type.h FT232R_Emulator_VendorRequest.c FT232R_Emulator_VendorRequest.h main.c
  group Source/STM32F0XX
    Source/STM32F0XX/: FT232R_Emulator_BSP.c FT232R_Emulator_BSP_Conf.h FT232R_Emulator_Conf.h
