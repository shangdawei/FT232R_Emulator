# IAR project FT232R_Emulator_Application.ewp, settings and files
configuration STM32F10X_Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EXT_CLOCK=8000000; SYS_CLOCK=72000000; STM32F103XE; DEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\c; $TOOLKIT_DIR$\CMSIS\Include; Source; Common\Algorithm; Common\Component; Common\Debug; Common\Driver; Common\Misc; Common\RTOS; Common\USB; MCU\STM32F10X\Driver; MCU\STM32F10X\Library\CMSIS; MCU\STM32F10X\Library\SPL; MCU\STM32F10X\Library\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32F103XE
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MCU\STM32F10X\Linker\stm32f10x_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F10X_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: EXT_CLOCK=8000000; SYS_CLOCK=72000000; STM32F103XE
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCU\STM32F10X\Linker\stm32f10x_app.icf
configuration STM32F0XX_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  General.CoreVariant: 34
  ICCARM.CCDefines: EXT_CLOCK=8000000; SYS_CLOCK=48000000; STM32F072CB; DEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\c; $TOOLKIT_DIR$\CMSIS\Include; Source; Source\STM32F0XX; Common\Algorithm; Common\Component; Common\Debug; Common\Driver; Common\Misc; Common\RTOS; Common\USB; MCU\STM32F0XX\Driver; MCU\STM32F0XX\Library\CMSIS; MCU\STM32F0XX\Library\SPL; MCU\STM32F0XX\Library\USB
  AARM.ADefines: STM32F072VB
  ILINK.IlinkIcfFile: MCU\STM32F0XX\Linker\stm32f0xx_sram.icf
configuration STM32F0XX_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  General.CoreVariant: 34
  ICCARM.CCDefines: EXT_CLOCK=8000000; SYS_CLOCK=48000000; STM32F072CB
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: STM32F072VB
  ILINK.IlinkIcfFile: MCU\STM32F0XX\Linker\stm32f0xx_app.icf
  group Source
    Source/: main.c
